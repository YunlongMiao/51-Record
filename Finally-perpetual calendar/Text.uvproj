# Keil uVision project Text.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: Text +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Fin_12864.c Fin_iic.c Fin_main.c Fin_conversion.c
